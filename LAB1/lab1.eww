<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\LAB2\lab2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LAB3\Lab3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lab_1.ewp</path>
    </project>
    <batchBuild />
</workspace>
